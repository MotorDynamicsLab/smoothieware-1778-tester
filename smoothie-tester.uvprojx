# Keil uVision project smoothie-tester.uvprojx, settings and files
target smoothie (ARM-ADS)
  device: LPC1778 NXP
  pack: Keil.LPC1700_DFP.2.5.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: smoothie-tester +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: .\BSPSupport\CMSIS\Include;.\BSPSupport\Device\NXP\LPC177x_8x\Include;.\BSPSupport\Drivers\include;.\Application\Peripheral\include;.\Application\USBDevice\include;.\Application\EasyWeb\include;.\Application\Fatfs
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Startup
    ./BSPSupport/Device/NXP/LPC177x_8x/Source/: startup_LPC177x_8x.s
  group CMSIS-CM3
    ./BSPSupport/Device/NXP/LPC177x_8x/Source/: system_LPC177x_8x.c
  group Driver
    ./BSPSupport/Drivers/source/: debug_frmwrk.c lpc177x_8x_adc.c lpc177x_8x_clkpwr.c lpc177x_8x_emac.c lpc177x_8x_gpio.c lpc177x_8x_nvic.c lpc177x_8x_pinsel.c lpc177x_8x_ssp.c lpc177x_8x_uart.c lpc177x_8x_timer.c
  group Peripheral
    ./Application/Peripheral/source/: LED.c SDCard.c SPI.c TMC2660.c Uart.c Motor.c Timer.c phylan.c
  group USBDevice
    ./Application/USBDevice/source/: DiskImg.c memory.c mscuser.c usbcore.c usbdesc.c usbhw.c usbuser.c
  group EasyWeb
    ./Application/EasyWeb/source/: EMAC.c Emac_EasyWeb.c tcpip.c
  group Fatfs
    ./Application/Fatfs/: diskio.c ff.c
    ./Application/Fatfs/option/: ccsbcs.c syscall.c unicode.c
  group Main
    ./Application/Main/: main.c
